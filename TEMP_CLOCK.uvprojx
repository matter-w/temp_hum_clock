# Keil uVision project TEMP_CLOCK.uvprojx, settings and files
target TEMP_CLOCK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: TEMP_CLOCK +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./common;./freertos;./freertos/include;./freertos/portable;./freertos/source;./application;./initerface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group common
    ./common/: common.c common.h
  group FreeRTOS
    ./freertos/: FreeRTOSConfig.h
  group FreeRTOS/sourse
    ./freertos/source/: croutine.c event_groups.c list.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ./freertos/include/: atomic.h CMakeLists.txt croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable
    ./freertos/portable/: heap_4.c port.c portmacro.h
  group application
    ./application/: APP_freertos.c APP_freertos.h APP_dateime.c APP_dateime.h APP_show.c APP_show.h APP_switch.c APP_switch.h
  group initerface
    ./initerface/: init_key.c init_key.h init_touch.c init_touch.h init_mic.c init_mic.h init_ds1302z.c init_ds1302z.h init_dht11.c init_dht11.h init_nv020d.c init_nv020d.h init_led.c init_led.h
software components: CMSIS:CORE 4.3.0
